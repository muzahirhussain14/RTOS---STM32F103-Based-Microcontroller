# Keil uVision project Mutex_Semaphores_LOCKS.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mutex_Semaphores_LOCKS +hex
  group Source Group 1
    ./: main.c startup_stm32f10x_md.s
