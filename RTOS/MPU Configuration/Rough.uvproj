# Keil uVision project Rough.uvproj, settings and files
target Target 1 (ARM-GNU)
  device: STM32F417IE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Rough +hex
  group Source Group 1
    ./: rough.c startup_stm32f10x_md.s
